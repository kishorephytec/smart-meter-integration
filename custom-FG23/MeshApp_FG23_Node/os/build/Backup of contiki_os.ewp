# IAR project Backup of contiki_os.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG23A020F512GM40 SiliconLaboratories EFR32FG23A020F512GM40
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32FG23A020F512GM40=1
  ICCARM.CCIncludePath2: ..\..\ProAppSrc\AppConfigs; ..\; ..\inc; ..\cpu; ..\platform\p3_lp_dk; ..\..\ProAppSrc\wisun_modified\inc; ..\..\L3\L2_L3_interface\inc; ..\..\L3\inc; ..\..\L3\OS_interface\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: contiki_os.srec
  ILINK.IlinkOutputFile: contiki_os.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group src
    ../lib/: assert.c list.c memb.c random.c
    ../src/: ctimer.c etimer.c process.c stimer.c timer.c

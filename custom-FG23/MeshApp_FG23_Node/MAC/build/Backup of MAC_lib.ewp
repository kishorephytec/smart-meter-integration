# IAR project Backup of MAC_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG23A020F512GM40 SiliconLaboratories EFR32FG23A020F512GM40
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32FG23A020F512GM40=1
  ICCARM.CCIncludePath2: ..\..\ProAppSrc\AppConfigs; ..\..\MAC\Inc; ..\..\ProAppSrc\Include; ..\..\ProAppSrc\Util\list_manager; ..\..\ProAppSrc\Util\queue_manager; ..\..\os\inc; ..\..\os; ..\..\ProAppSrc\Util\timer_manager; ..\..\ProAppSrc\Util\buffer_manager; ..\..\ProAppSrc\HAL; ..\..\ProAppSrc\Util\event_manager; ..\..\ProAppSrc\Util\timer_manager; ..\..\ProAppSrc\Util\hif; ..\..\L3\inc; ..\..\L3\OS_interface\inc; ..\..\ProAppSrc\wisun_modified\inc; ..\..\PHY\Inc; ..\..\PHY\RAIL_TRX; ..\..\L3\OS_interface\inc; ..\..\os; ..\..\os\inc; ..\..\os\cpu; ..\..\L3\ip\inc; ..\..\L3\ipv6\multicast\inc; ..\..\L3\ipv6\inc; ..\..\L3\rpl; ..\..\L3\inc; ..\..\L3\OS_interface\inc; ..\..\sha256\inc; ..\..\SiliconLabs\platform\emlib\inc; ..\..\PHY\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\PHY\radio\rail_lib\common; ..\..\SiliconLabs\platform\Device\SiliconLabs\EFR32FG23\Include; ..\..\SiliconLabs\platform\CMSIS\Core\Include; ..\..\DebugLog\APP_LOG; ..\..\DebugLog\response_print\config; ..\..\DebugLog\response_print; ..\..\SiliconLabs\platform\service\iostream\inc; ..\..\SiliconLabs\platform\emdrv\dmadrv\inc; ..\..\SiliconLabs\platform\emdrv\common\inc; ..\..\SiliconLabs\platform\common\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MAC_lib.srec
  ILINK.IlinkOutputFile: MAC_lib.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group rail_timer
    ../Src/: rail_timer_interface.c
  group sha_256
    ../../sha256/src/: sha256.c
  group Src
    ../Src/: ccasm.c dh1cf.c fan_mac_freq_hopping.c fan_sm.c ie_manager.c jenkins_hash.c mac_data.c mac_downlink.c mac_frame_build.c mac_frame_parse.c mac_if.c mac_interface_layer.c mac_mem.c mac_nbr_manager.c mac_pib.c mac_queue_manager.c mac_rcv.c mac_security.c mac_uplink.c macproc.c macutils.c p3_aes.c p3_ccmstar.c pa_tmr.c pas_tmr.c pc_tmr.c pcs_tmr.c set_tri_timer.c trxsm.c
    ../../Interface_Layer/contiki_mac_interface_layer/: contiki_mac_interface.c
    ../../ProAppSrc/wisun_modified/src/: mac_timer.c

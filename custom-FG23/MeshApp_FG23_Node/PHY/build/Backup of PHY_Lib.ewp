# IAR project Backup of PHY_Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG23A020F512GM40 SiliconLaboratories EFR32FG23A020F512GM40
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32FG23A020F512GM40=1; SL_COMPONENT_CATALOG_PRESENT=1; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>
  ICCARM.CCIncludePath2: ..\..\ProAppSrc\AppConfigs; ..\Inc; ..\RAIL_TRX; ..\..\ProAppSrc\Include; ..\radio; ..\..\ProAppSrc\HAL; ..\radio\rail_lib\common; ..\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\SiliconLabs\platform\Device\SiliconLabs\EFR32FG23\Include; ..\..\SiliconLabs\platform\CMSIS\Core\Include; ..\radio\rail_lib\plugin\rail_util_callbacks; ..\radio\rail_lib\plugin\pa-conversions; ..\radio\rail_lib\plugin\pa-conversions\efr32xg1x; ..\radio\rail_lib\plugin\rail_util_protocol; ..\radio\rail_lib\plugin\rail_util_pti; ..\radio\rail_lib\plugin\rail_util_rssi; ..\radio\rail_lib\protocol\ble; ..\radio\rail_lib\protocol\ieee802154; ..\radio\rail_lib\protocol\zwave; ..\..\SiliconLabs\platform\emlib\inc; ..\..\SiliconLabs\platform\common\inc; ..\..\SiliconLabs\config; ..\..\SiliconLabs\autogen; ..\..\DebugLog\APP_LOG; ..\..\DebugLog\response_print\config; ..\..\DebugLog\response_print; ..\..\SiliconLabs\platform\service\iostream\inc; ..\..\SiliconLabs\platform\emdrv\dmadrv\inc; ..\..\SiliconLabs\platform\emdrv\common\inc; ..\..\SiliconLabs\platform\common\inc; ..\radio\rail_lib\protocol\sidewalk
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PHY_Lib.srec
  ILINK.IlinkOutputFile: PHY_Lib.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group radio
    ../radio/: rail_config.c rail_config.h sl_rail_util_callbacks.c
  group radio/rail_lib/chip/efr32/efr32xg2x
    ../radio/rail_lib/chip/efr32/efr32xg2x/: rail_chip_specific.h
  group radio/rail_lib/common
    ../radio/rail_lib/common/: rail.h rail_assert_error_codes.h rail_features.h rail_mfm.h rail_types.h
  group radio/rail_lib/plugin/pa-conversions
    ../radio/rail_lib/plugin/pa-conversions/: pa_conversions_efr32.c pa_conversions_efr32.h pa_curve_types_efr32.h pa_curves_efr32.c pa_curves_efr32.h
  group radio/rail_lib/plugin/pa-conversions/efr32xg23
    ../radio/rail_lib/plugin/pa-conversions/efr32xg23/: sl_rail_util_pa_curves_10dbm_434M.h sl_rail_util_pa_curves_14dbm.h sl_rail_util_pa_curves_20dbm.h
  group radio/rail_lib/plugin/rail_util_callbacks
    ../radio/rail_lib/plugin/rail_util_callbacks/: sl_rail_util_callbacks.h sli_rail_util_callbacks.h
  group radio/rail_lib/plugin/rail_util_protocol
    ../radio/rail_lib/plugin/rail_util_protocol/: sl_rail_util_protocol.c sl_rail_util_protocol.h sl_rail_util_protocol_types.h
  group radio/rail_lib/plugin/rail_util_pti
    ../radio/rail_lib/plugin/rail_util_pti/: sl_rail_util_pti.c sl_rail_util_pti.h
  group radio/rail_lib/plugin/rail_util_rssi
    ../radio/rail_lib/plugin/rail_util_rssi/: sl_rail_util_rssi.c sl_rail_util_rssi.h
  group radio/rail_lib/protocol/ble
    ../radio/rail_lib/protocol/ble/: rail_ble.h
  group radio/rail_lib/protocol/ieee802154
    ../radio/rail_lib/protocol/ieee802154/: rail_ieee802154.h
  group radio/rail_lib/protocol/zwave
    ../radio/rail_lib/protocol/zwave/: rail_zwave.h
  group Src
    ../Src/: pd.c phy.c plme.c
    ../RAIL_TRX/: trx_access.c

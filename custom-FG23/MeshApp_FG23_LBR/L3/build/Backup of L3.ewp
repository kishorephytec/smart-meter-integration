# IAR project Backup of L3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG23A020F512GM40 SiliconLaboratories EFR32FG23A020F512GM40
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32FG23A020F512GM40=1
  ICCARM.CCIncludePath2: ..\..\ProAppSrc\AppConfigs; ..\inc; ..\ip\inc; ..\ipv6\inc; ..\ipv6\multicast\inc; ..\rpl; ..\rpl; ..\OS_interface\inc; ..\ipv6\multicast\inc; ..\..\ProAppSrc\wisun_modified\inc; ..\..\os\inc; ..\..\os\cpu; ..\..\os\platform\p3_lp_dk; ..\..\os; ..\..\ProAppSrc\Include; ..\..\ProAppSrc\Util\list_manager; ..\..\ProAppSrc\Util\queue_manager; ..\..\ProAppSrc\Util\timer_manager; ..\..\ProAppSrc\Util\buffer_manager; ..\L2_L3_interface\inc; ..\..\MAC\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: L3.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
  group ip
    ../ip/src/: simple-udp.c tcpip.c uip-debug.c uip-packetqueue.c uip-udp-packet.c
  group ipv6
    ../ipv6/src/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group ipv6/multicast
    ../ipv6/multicast/src/: mpl.c roll-tm.c uip-mcast6-route.c uip-mcast6-stats.c
  group L2_L3_interface
    ../L2_L3_interface/src/: l2_l3_interface.c
  group OS_interface
    ../OS_interface/src/: l3_list_utility.c l3_memb_utility.c l3_process_interface.c l3_random_utility.c l3_timer_utility.c
  group rpl
    ../rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group wisun_l3_modified
    ../../ProAppSrc/wisun_modified/src/: wisun_l3_modified.c

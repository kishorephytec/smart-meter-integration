# IAR project Backup of ProNICApp.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG23A020F512GM40 SiliconLaboratories EFR32FG23A020F512GM40
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: EFR32FG23A020F512GM40=1; SL_COMPONENT_CATALOG_PRESENT=1; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\ProAppSrc\AppConfigs; ..\SiliconLabs\config; ..\SiliconLabs\autogen; ..\ProAppSrc\HAL; ..\ProAppSrc\NVM; ..\ProAppSrc\Include; ..\ProAppSrc\Util\buffer_manager; ..\ProAppSrc\Util\event_manager; ..\ProAppSrc\Util\list_manager; ..\ProAppSrc\Util\queue_manager; ..\ProAppSrc\Util\timer_manager; ..\ProAppSrc\Util\hif; ..\ProAppSrc\Util\raw_uart_if; ..\ProAppSrc\Util\debug_console; ..\SiliconLabs\platform\Device\SiliconLabs\EFR32FG23\Include; ..\SiliconLabs\platform\CMSIS\Core\Include; ..\SiliconLabs\platform\service\device_init\inc; ..\SiliconLabs\platform\common\inc; ..\SiliconLabs\platform\service\mpu\inc; ..\SiliconLabs\platform\common\toolchain\inc; ..\SiliconLabs\platform\service\system\inc; ..\ProAppSrc\network-manager; ..\PHY\RAIL_TRX; ..\MAC\Inc; ..\ProAppSrc\wisun_modified\inc; ..\ProAppSrc\FANApp\AppInc; ..\PHY\radio\rail_lib\plugin\rail_util_callbacks; ..\L3\ip\inc; ..\L3\ipv6\multicast\inc; ..\L3\ipv6\inc; ..\L3\rpl; ..\L3\inc; ..\L3\OS_interface\inc; ..\L3\L2_L3_interface\inc; ..\os; ..\os\inc; ..\os\cpu; ..\Interface_Layer\contiki_mac_interface_layer; ..\Interface_Layer\mac_sicslowpan_if; ..\SiliconLabs\platform\emlib\inc; ..\os\platform\p3_lp_dk; ..\PHY\radio\rail_lib\common; ..\PHY\radio\rail_lib\chip\efr32\efr32xg2x; ..\PHY\radio\rail_lib\protocol\ble; ..\PHY\radio\rail_lib\protocol\ieee802154; ..\PHY\radio\rail_lib\protocol\zwave; ..\PHY\radio\rail_lib\plugin\pa-conversions; ..\PHY\radio\rail_lib\plugin\pa-conversions\efr32xg1x; ..\PHY\radio\rail_lib\plugin\rail_util_protocol; ..\PHY\radio\rail_lib\plugin\rail_util_pti; ..\PHY\radio\rail_lib\plugin\rail_util_rssi; ..\PHY\radio; ..\MeterApp\Inc; ..\SiliconLabs\platform\service\iostream\inc; ..\SiliconLabs\platform\emdrv\dmadrv\inc; ..\SiliconLabs\platform\emdrv\common\inc; ..\FLASH; ..\DebugLog\APP_LOG; ..\DebugLog\response_print\config; ..\DebugLog\response_print; ..\NVM\nvm3\inc; ..\SiliconLabs\platform\service\iostream\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG13P231F512GM32=1; SL_COMPONENT_CATALOG_PRESENT=1; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>
  AARM.AUserIncludes: $FILE_DIR$; config; autogen; .; gecko_sdk_4.1.0\platform\Device\SiliconLabs\EFR32FG13P\Include; gecko_sdk_4.1.0\platform\CMSIS\Core\Include; gecko_sdk_4.1.0\platform\service\device_init\inc; gecko_sdk_4.1.0\platform\emlib\inc; gecko_sdk_4.1.0\platform\common\inc; gecko_sdk_4.1.0\platform\service\mpu\inc; gecko_sdk_4.1.0\platform\radio\rail_lib\common; gecko_sdk_4.1.0\platform\radio\rail_lib\protocol\ble; gecko_sdk_4.1.0\platform\radio\rail_lib\protocol\ieee802154; gecko_sdk_4.1.0\platform\radio\rail_lib\protocol\zwave; gecko_sdk_4.1.0\platform\radio\rail_lib\chip\efr32\efr32xg1x; gecko_sdk_4.1.0\platform\radio\rail_lib\plugin\rail_util_callbacks; gecko_sdk_4.1.0\platform\radio\rail_lib\plugin\pa-conversions; gecko_sdk_4.1.0\platform\radio\rail_lib\plugin\pa-conversions\efr32xg1x; gecko_sdk_4.1.0\platform\radio\rail_lib\plugin\rail_util_protocol; gecko_sdk_4.1.0\platform\radio\rail_lib\plugin\rail_util_pti; gecko_sdk_4.1.0\platform\radio\rail_lib\plugin\rail_util_rssi; gecko_sdk_4.1.0\platform\common\toolchain\inc; gecko_sdk_4.1.0\platform\service\system\inc
  OBJCOPY.OOCOutputFile: ProNICApp.s37
  ILINK.IlinkOutputFile: ProNICApp.out
  ILINK.IlinkIcfFile: ..\SiliconLabs\autogen\linkerfile.icf
  group (top)
    ./: app_init.c app_init.h app_process.c app_process.h main.c sl_iostream_eusart_vcom_config.h sl_iostream_init_eusart_instances.c sl_iostream_init_instances.h
  group APPSrc/Fan_app/Inc
    ../ProAppSrc/FANApp/AppInc/: AppUDPprocess.h eeprom_emulation.h fan_api.h fan_app_auto.h fan_app_test_harness.h fan_config_param.h fan_factorycmd.h wdog.h
  group APPSrc/Fan_app/Src
    ../ProAppSrc/FANApp/AppSrc/: AppPING6Process.c AppUDPprocess.c eeprom_emulation.c fan_api.c fan_app_auto.c fan_app_test_harness.c fan_factorycmd.c
    ../ProAppSrc/NVM/: nvm_app.c
  group APPSrc/HAL
    ../os/cpu/: clock.c
    ../ProAppSrc/HAL/: hw_sec.c hw_tmr.c hw_tmr.h uart_hal.c uart_hal.h
  group APPSrc/network_manager
    ../ProAppSrc/network-manager/: app_mac_security_interface.c network-manager.c
  group APPSrc/Util
    ../ProAppSrc/Util/buffer_manager/: buff_mgmt.c buff_mgmt.h buffer_service.c buffer_service.h
    ../ProAppSrc/Util/event_manager/: event_manager.c event_manager.h
    ../ProAppSrc/Util/hif/: hif_process.c hif_service.c hif_service.h hif_utility.c hif_utility.h
    ../ProAppSrc/Util/list_manager/: list_latest.c list_latest.h
    ../ProAppSrc/Util/queue_manager/: queue_latest.c queue_latest.h
    ../ProAppSrc/Util/timer_manager/: sw_timer.c sw_timer.h timer_service.c timer_service.h
  group autogen
    ../SiliconLabs/autogen/: RTE_Components.h sl_component_catalog.h sl_device_init_clocks.c sl_event_handler.c sl_event_handler.h
  group config
    ../SiliconLabs/config/: emlib_core_debug_config.h pin_config.h sl_device_init_dcdc_config.h sl_device_init_emu_config.h sl_device_init_hfxo_config.h sl_memory_config.h
  group DebugLog/APP_LOG
    ../DebugLog/APP_LOG/: app_log.c app_log.h app_log_config.h sl_app_log.h sl_iostream_handles.h sl_iostream_init_eusart_instances.h
  group FLASH
    ../FLASH/: ext_FLASH_app.c ext_FLASH_app.h mx25flash_config.h mx25flash_spi.c mx25flash_spi.h
  group LIBS
    ../libraries/: 80154_PHY_Lib.a 802154_MAC_lib.a ContikiOS_lib.a RPL_IPv6_Lib.a
    ../PHY/radio/rail_lib/autogen/librail_release/: librail_efr32xg23_iar_release.a
  group MeterApp
    ../MeterApp/src/: meterReading.c
  group NVM/Inc
    ../NVM/nvm3/inc/: nvm3.h nvm3_default.h nvm3_default_config.h nvm3_generic.h nvm3_hal.h nvm3_hal_flash.h nvm3_lock.h
  group NVM/Lib
    ../NVM/nvm3/lib/: libnvm3_CM33_iar.a
  group NVM/Src
    ../NVM/nvm3/src/: nvm3_default_common_linker.c nvm3_hal_flash.c nvm3_lock.c
  group platform/CMSIS/Core/Include
    ../SiliconLabs/platform/CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h tz_context.h
  group platform/common/inc
    ../SiliconLabs/platform/common/inc/: sl_assert.h sl_common.h sl_enum.h sl_status.h
  group platform/common/src
    ../SiliconLabs/platform/common/src/: sl_assert.c
  group platform/common/toolchain/inc
    ../SiliconLabs/platform/common/toolchain/inc/: sl_memory.h sl_memory_region.h
  group platform/common/toolchain/src
    ../SiliconLabs/platform/common/toolchain/src/: sl_memory.c
  group platform/Device/SiliconLabs/EFR32FG23/Source
    ../SiliconLabs/platform/Device/SiliconLabs/EFR32FG23/: startup_efr32fg23.c system_efr32fg23.c
  group platform/emdrv/common/inc
    ../SiliconLabs/platform/emdrv/common/inc/: ecode.h
  group platform/emdrv/dmadrv/inc
    ../SiliconLabs/platform/emdrv/dmadrv/inc/: dmadrv.h
  group platform/emdrv/dmadrv/src
    ../SiliconLabs/platform/emdrv/dmadrv/src/: dmadrv.c
  group platform/emlib/inc
    ../SiliconLabs/platform/emlib/inc/: em_assert.h em_bus.h em_chip.h em_cmu.h em_cmu_compat.h em_common.h em_core.h em_emu.h em_eusart.h em_gpio.h em_ldma.h em_leuart.h em_msc.h em_msc_compat.h em_prs.h em_ramfunc.h em_system.h em_version.h
  group platform/emlib/src
    ../SiliconLabs/platform/emlib/src/: em_cmu.c em_core.c em_crypto.c em_emu.c em_eusart.c em_gpio.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
  group platform/service/device_init/inc
    ../SiliconLabs/platform/service/device_init/inc/: sl_device_init_clocks.h sl_device_init_dcdc.h sl_device_init_emu.h sl_device_init_hfxo.h sl_device_init_nvic.h
  group platform/service/device_init/src
    ../SiliconLabs/platform/service/device_init/src/: sl_device_init_dcdc_s1.c sl_device_init_emu_s1.c sl_device_init_hfxo_s1.c sl_device_init_nvic.c
  group platform/service/iostream/inc
    ../SiliconLabs/platform/service/iostream/inc/: sl_iostream.h sl_iostream_eusart.h sl_iostream_uart.h sli_iostream_uart.h
  group platform/service/iostream/src
    ../SiliconLabs/platform/service/iostream/src/: sl_iostream.c sl_iostream_eusart.c sl_iostream_retarget_stdio.c sl_iostream_uart.c
  group platform/service/mpu/inc
    ../SiliconLabs/platform/service/mpu/inc/: sl_mpu.h
  group platform/service/mpu/src
    ../SiliconLabs/platform/service/mpu/src/: sl_mpu.c
  group platform/service/system/inc
    ../SiliconLabs/platform/service/system/inc/: sl_system_init.h sl_system_process_action.h
  group platform/service/system/src
    ../SiliconLabs/platform/service/system/src/: sl_system_init.c sl_system_process_action.c
